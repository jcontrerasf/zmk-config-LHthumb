## boards/shields/lhthumb/Kconfig.defconfig
```kconfig
if SHIELD_LHTHUMB

config ZMK_KEYBOARD_NAME
    default "LHthumb"

endif # SHIELD_LHTHUMB
```
